FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " file://pwm-cdev.cfg"
SRC_URI += " file://rauc-kernel.cfg"
